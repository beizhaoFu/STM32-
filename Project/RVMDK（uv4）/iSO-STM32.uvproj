# Keil uVision project iSO-STM32.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\oled;..\..\User\MPU6050_DMP;..\..\User\MPU6050_DMP\DMP;..\..\User\MPU6050_DMP\iic;..\..\User\systick;..\..\User\tim;..\..\User\uart;..\..\User\tim;..\..\User\encode;..\..\User\motor;..\..\User\app;..\..\User\remote;..\..\User\exti;..\..\User\HC-SR04
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/oled/: oled.c
    ../../User/systick/: systick.c
    ../../User/MPU6050_DMP/: mpu6050.c
    ../../User/MPU6050_DMP/iic/: ctiic.c
    ../../User/MPU6050_DMP/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/encode/: encode.c
    ../../User/motor/: motor.c
    ../../User/tim/: timh.c
    ../../User/app/: app.c
    ../../User/uart/: usart.c
    ../../User/remote/: remote.c
    ../../User/exti/: exti.c
    ../../User/HC-SR04/: hcsr04.c
